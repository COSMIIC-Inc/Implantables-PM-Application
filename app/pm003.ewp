# IAR project pm003.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC2129 NXP LPC2129
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_ODICT_DEFAULTS
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\bsp; ..\uC\uC-CPU; ..\uC\uC-CPU\ARM\IAR; ..\uC\uC-LIB; ..\uC\uC-CAN\Cfg; ..\uC\uC-OS3\Ports\ARM\Generic\IAR; ..\uC\uC-OS3\Cfg; ..\uC\uC-OS3\Source; ..\uC\uC-LIB\Cfg; ..\canFest\app; ..\canFest\include; ..\canFest\include\ucCan; ..\canFest\source; ..\canFest\source\ucCan; ..\uC\uC-CPU\Cfg; ..\uC\uC-CAN\Drivers; ..\uC\uC-CAN\Drivers\BSP; ..\uC\uC-CAN\Drivers\LPC21XX; ..\uC\uC-CAN\OS\uCOS-III; ..\uC\uC-CAN\Source; ..\uC\uC-CAN\Cfg
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: pm003.bin
  ILINK.IlinkOutputFile: pm003.out
  ILINK.IlinkIcfFile: ..\bsp\lpc212x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: D:\Repositories\JDC\PM003\trunk\uCarm\uC-CPU\ARM\IAR; D:\Repositories\JDC\PM003\trunk\uCarm\uC-CPU; D:\Repositories\JDC\PM003\trunk\uCarm\uC-LIB; D:\Repositories\JDC\PM003\trunk\uCarm\can; D:\Repositories\JDC\PM003\trunk\uCarm\osIII; D:\Repositories\JDC\PM003\trunk\uCarm\uC-CRC\Source; D:\Repositories\JDC\PM003\trunk\canFest\include\ucCan; D:\Repositories\JDC\PM003\trunk\canFest\include; D:\Repositories\JDC\PM003\trunk\canFest\app; D:\Repositories\JDC\PM003\trunk\bsp; D:\Repositories\JDC\PM003\trunk\app
  ICCARM.CCOptLevel: 3
  group App
    ./: app.c app_cfg.h File_Operations.c gateway.c gateway.h includes.h RMBootloader.c runcanserver.c ScriptInterpreter.c scripts.c sys.h
  group App/BSP
    ../bsp/: accelKxt.c batPack.c bsp.c caseTherm.c cc1101radio.c cpuFlash.c cstartup.s i2c.c pwrnet.c SPI_Memory.c
    ./: iolpc2129_iopin_rw.h
  group CANFestival
    ../canFest/source/ucCan/: can_ucCan.c timer_ucCan.c
    ../canFest/source/: emcy.c lifegrd.c lss.c nmtMaster.c nmtSlave.c objacces.c pdo.c sdo.c states.c sync.c timer.c
    ../canFest/app/: ObjDict.c
  group uC/uC-CAN
    ../uC/uC-CAN/Source/: can_bus.c can_frm.c can_msg.c can_sig.c
  group uC/uC-CAN/Cfg
    ../uC/uC-CAN/Cfg/: can_cfg.c
  group uC/uC-CAN/Drivers/BSP
    ../uC/uC-CAN/Drivers/BSP/: can_bsp.c
  group uC/uC-CAN/Drivers/LC21XX
    ../uC/uC-CAN/Drivers/LPC21XX/: drv_can.c
  group uC/uC-CAN/OS
    ../uC/uC-CAN/OS/uCOS-III/: can_os.c
  group uC/uC-CPU
    ../uC/uC-CPU/ARM/IAR/: cpu_a.s
    ../uC/uC-CPU/: cpu_core.c
  group uC/uC-LIB
    ../uC/uC-LIB/: lib_ascii.c lib_str.c
  group uC/uC-OS3
    ../uC/uC-OS3/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group uC/uC-OS3/Cfg
    ../uC/uC-OS3/Cfg/: os_app_hooks.c
  group uC/uC-OS3/Ports
    ../uC/uC-OS3/Ports/ARM/Generic/IAR/: os_cpu_a.asm os_cpu_c.c
